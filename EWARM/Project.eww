<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LAB2LYN.ewp</path>
  </project>
  <batchBuild />
</workspace>
